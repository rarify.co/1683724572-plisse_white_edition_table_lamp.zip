Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Lighting_Desk-Table_Orsjo-Belysning_Plisse-White-Edition.ifc
Time: 2022-05-23T11:21:57
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Plissé White Edition
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Plissé White Edition; SKU (BO_prodsku): Plisse_White_edition_Table_lamp; ManufacturName (BO_Manufac): Örsjö Belysning; BrandUrl (BO_brandurl): http://www.orsjo.com; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/orsjo/product/Plisse_White_edition_Table_lamp; ProductDataUrl (BO_prodaturl): bimobject.com/orsjo/product/Plisse_White_edition_Table_lamp; BimObjectMainCategory (BO_bomaincat): Lighting; BimObjectMainCategoryCode (BO_bomaincat_code): lighting; BimObjectCategory (BO_bocat): Desk & Table; BimObjectCategoryCode (BO_bocat_code): desk-table-lighting; IfcClassification (BO_ifcclas): Lamp; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
